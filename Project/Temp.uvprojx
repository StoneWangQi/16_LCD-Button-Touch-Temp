# Keil uVision project Temp.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Temp +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,__STM32103ZET6,_USE_LFN,_USEUSARTSHOW
  c include: ..\Libraries\DRIVER\CMISIS;..\Libraries\DRIVER\DEVICE\startup;..\Libraries\SYSTEM;..\Libraries\STMLIB\inc;..\Libraries\PROLIB\inc;..\User;..\Libraries\PROLIB\FATFS;..\Libraries\PROLIB\FONT
  asm include: ..\Libraries\DRIVER\CMISIS;..\Libraries\DRIVER\DEVICE\startup;..\Libraries\SYSTEM;..\Libraries\STMLIB\inc;..\Libraries\PROLIB\inc;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group DRIVER
    ../Libraries/DRIVER/DEVICE/startup/: startup_stm32f10x_hd.s
  group SYSTEM
    ../Libraries/SYSTEM/: system_stm32f10x.c
  group STMLIB
    ../Libraries/STMLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group PROLIB
    ../Libraries/PROLIB/src/: Exit_book.c Key_book.c Led_book.c RCC_book.c Systick_book.c USART_book.c DMA_book.c I2C_book.c I2C_soft_book.c SPI_book.c FatFs_book.c SRAM_book.c LCD_book.c LCD_Draw_book.c LCD_PageHtml_book.c XPT2046_LCD_book.c XPT2046_LCD_Function_book.c XPT2046_LCD_Device_book.c ADC_book.c
  group FatFs
    ../Libraries/PROLIB/FATFS/: diskio.c ff.c
    ../Libraries/PROLIB/FATFS/option/: cc936.c
  group Font
    ../Libraries/PROLIB/FONT/: fonts.c
  group USER
    ../User/: main.c stm32f10x_it.c
